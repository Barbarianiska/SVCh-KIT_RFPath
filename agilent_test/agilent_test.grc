options:
  parameters:
    author: Пользователь
    generate_options: qt_gui
    id: agilent_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '200'
    value: '100'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    start: pi/200
    step: pi/10000
    stop: 2*pi/100
    value: pi/100
  states: {}
- name: nop
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: E:\output_gnuradio.bin
    type: float
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: E:\test.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\agilent data\asciixy_1.csv
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: C:\agilent data\asciixy_2.csv
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_2
  id: blocks_file_source
  parameters:
    file: E:\output.bin
    repeat: 'True'
    type: short
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Uspan = 10 
      (Voltage span, taken 
      from the ISVI file format)

      LSDspan = 4096 (Least 
      Significant Digit span, 
      taken from the ISVI file format)
    const: 10/4096
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_throttle2_1_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\r\nfrom gnuradio import gr\r\n\r\nclass adc_block(gr.sync_block):\r\n    def __init__(self, samp_rate=32000, fsym=200):\r\n        # Инициализация блока\r\n        gr.sync_block.__init__(self,\r\n                               name=\"adc_block\",\r\n                               in_sig=[np.float32],\r\n                               out_sig=[np.uint8])\r\n        self.samp_rate = samp_rate\r\n        self.fsym = fsym\r\n        self.N_sym = int(samp_rate / fsym)\r\n\r\n    def work(self, input_items, output_items):\r\n        in0 = input_items[0]  # Входной массив\r\n        out = output_items[0]  # Выходной массив\r\n        num_symbols = len(in0) // self.N_sym  # Количество символов\r\n        out_idx = 0  # Индекс для записи в выходной массив\r\n        print (self.N_sym)\r\n        for i in range(num_symbols):\r\n            \r\n            symbol = in0[i * self.N_sym: (i + 1) * self.N_sym]  # Извлечение символа\r\n            max_val = np.max(symbol)-40  # Максимальное значение символа\r\n            min_val = np.min(symbol)-40  # Минимальное значение символа\r\n            \r\n            # Установка старшего и младшего битов\r\n            high_signal = max_val > 10\r\n            low_signal = min_val < -10\r\n\r\n            if high_signal and low_signal:\r\n                out[out_idx] = 0b11  # Сигнал и выше, и ниже нуля\r\n            elif high_signal:\r\n                out[out_idx] = 0b10  # Сигнал выше нуля\r\n            elif low_signal:\r\n                out[out_idx] = 0b01  # Сигнал ниже нуля\r\n            else:\r\n                out[out_idx] = 0b00  # Плоский сигнал\r\n            print (out[out_idx])\r\n            out_idx += 1  # Увеличение индекса выхода\r\n\r\n        return out_idx  # Возвращает количество записанных байтов\r\n"
    fsym: samp_rate/200
    samp_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: nop
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '3'
    min: '0'
    name: '"Decoded Number"'
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: nop
    srate: samp_rate
    type: float
    ymax: '100'
    ymin: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_1, '0']
- [blocks_add_xx_1, '0', blocks_throttle2_0, '0']
- [blocks_divide_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', blocks_add_xx_1, '0']
- [blocks_file_source_0, '0', blocks_divide_xx_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_sub_xx_0, '0']
- [blocks_file_source_1, '0', blocks_add_xx_1, '1']
- [blocks_file_source_1, '0', blocks_divide_xx_0, '1']
- [blocks_file_source_1, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_1, '0', blocks_sub_xx_0, '1']
- [blocks_file_source_2, '0', blocks_throttle2_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_2, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_sub_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_1, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_1_0_0, '0', blocks_short_to_float_0, '0']
- [epy_block_2, '0', blocks_file_sink_1, '0']
- [epy_block_2, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
